# Keil uVision project AutoDoor.uvprojx, settings and files
target AutoDoor (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x8000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AutoDoor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, HSE_VALUE=8000000
  c include: Core;App;Drivers\CMSIS;Drivers\StdPeriph;Hardware\Delay;Hardware\MyI2C;Hardware\OLED;Hardware\EEPROM;Hardware\UART;Hardware\Motor;Hardware\Limit;Hardware\Buzzer;Hardware\Input
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../Core/: main.c stm32f10x_it.c
  group Start
    ../Drivers/CMSIS/: startup_stm32f10x_md.s system_stm32f10x.c core_cm3.c
  group Library
    ../Drivers/StdPeriph/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_tim.c
  group App
    ../App/: Log.c Door.c Cmd.c Display.c Display_Oled.c Fmt.c
  group Hardware
    ../Hardware/Delay/: Delay.c
    ../Hardware/MyI2C/: MyI2C.c
    ../Hardware/OLED/: OLED.c OLED_Data.c
    ../Hardware/EEPROM/: EEPROM.c
    ../Hardware/UART/: UART.c
    ../Hardware/Motor/: Motor.c
    ../Hardware/Limit/: Limit.c
    ../Hardware/Buzzer/: Buzzer.c
    ../Hardware/Led/: StatusLed.c
    ../Hardware/Input/: Debounce.c Exti.c Sensor.c Key.c
